# IAR project OVULATION_MULTI_New.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: Core/STM8L15x_StdPeriph_Driver/inc; Core/main; USER; USER/App; USER/Drive; USER/Utill
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: OVULATION_MULTI_New.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Core/main
    Core/main/: main.c stm8l15x_it.c
  group Core/STM8L15x_StdPeriph_Driver
    Core/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group USER
    USER/: Parameter_define.h User_Main.c
  group USER/Application
    USER/App/: DM_LCD_Stick_Check_App.c DM_Main_Sq_App.c DM_Optic_Handle_App.c DM_Rom_Handl_App.c
  group USER/Drive
    USER/Drive/: DM_HW_Drv.c
  group USER/Utill
    USER/Utill/: DM_Utill.c
