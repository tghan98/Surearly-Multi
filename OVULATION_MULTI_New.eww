<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\OVULATION_MULTI_New.ewp</path>
    </project>
    <batchBuild />
</workspace>
